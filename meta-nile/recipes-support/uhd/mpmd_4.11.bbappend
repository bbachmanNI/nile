FILESEXTRAPATHS:prepend := "${THISDIR}/mpmd:"

SRC_URI:append = " file://0001-mpm-eeprom-specify-mode-for-open-with-O_CREAT.patch;patchdir=.."
